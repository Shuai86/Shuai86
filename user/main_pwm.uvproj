# Keil uVision project main_pwm.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: main_pwm +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\A01StudySoftware\Keil\C51;C:\A01StudySoftware\Keil\C51\INC\STC
  group Source Group 1
    ./: STARTUP.A51 m.c
